options:
  parameters:
    generate_options: qt_gui
    id: calibration_pll
    output_language: python
    title: grSDRCalibration
  states: {}

blocks:
- name: AUDIO_GAIN
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: AUDIO_SAMPLERATE
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: AUDIO_SELECT
  id: variable_qtgui_chooser
  parameters:
    label0: FM
    label1: AM
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '1'
  states: {}
- name: RF_FREQ
  id: variable
  parameters:
    value: '15000000'
  states: {}
- name: RF_SAMPLERATE
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '0.1'
    type: complex
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: '0.12265625'
    min_freq: '-0.12265625'
    w: '0.314'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: AUDIO_SAMPLERATE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int((RF_SAMPLERATE/4)/64)
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: int((RF_SAMPLERATE/4)/64)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (1/(2*3.14))*(RF_SAMPLERATE/4)*1e6/RF_FREQ
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(AUDIO_GAIN/20)
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: AUDIO_SELECT
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '4'
    gain: '1'
    samp_rate: RF_SAMPLERATE
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: int(RF_SAMPLERATE/4/AUDIO_SAMPLERATE)
    gain: '1'
    samp_rate: RF_SAMPLERATE/4
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: int(RF_SAMPLERATE/4/AUDIO_SAMPLERATE)
    gain: '1'
    samp_rate: RF_SAMPLERATE/4
    type: fir_filter_fff
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: AUDIO_SAMPLERATE
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '32768'
    name: Audio
    type: complex
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: '100'
    label1: ppm
    name: Histogram
    size: '1024'
    type: float
    xmax: '10'
    xmin: '-10'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Calibration
    name: Calibration
    type: float
    unit1: ppm
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    color1: ("white", "black")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: RSSI
    max: '0'
    min: '-150'
    name: RSSI
    type: float
    unit1: dBFS
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1/(RF_SAMPLERATE/4)
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1/( (RF_SAMPLERATE/4) * (1/10) )
    type: float
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    agc0: 'True'
    center_freq0: RF_FREQ
    dc_removal0: 'False'
    dev_args: '''direct_samp=2'' if RF_FREQ <23e6 else '''''
    driver: rtlsdr
    samp_rate: RF_SAMPLERATE
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0, '0', analog_pll_freqdet_cf_0, '0']
- [analog_agc2_xx_0, '0', low_pass_filter_0_0, '0']
- [analog_pll_freqdet_cf_0, '0', low_pass_filter_0_0_0, '0']
- [analog_pll_freqdet_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_selector_0, '1']
- [blocks_complex_to_mag_squared_0_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_1, '0']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [low_pass_filter_0, '0', analog_agc2_xx_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_selector_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [soapy_custom_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
